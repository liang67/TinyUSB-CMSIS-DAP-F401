# Keil uVision project 00-TINYUSB-DAPLINK.uvprojx, settings and files
target 00-TINYUSB-DAPLINK (6220000::V6.22::ARMCLANG)
  device: STM32F401CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: 00-TINYUSB-DAPLINK +hex
  AfterMake: keil-build-viewer
  AfterMake: fromelf --output $L@L.bin --bin #L
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F401xC,CFG_TUSB_MCU=OPT_MCU_STM32F4
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/tinyusb/src;../Middlewares/Third_Party/cmsis-dap/Include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/User/Core
    ../Core/Src/: main.c gpio.c usart.c usb_otg.c stm32f4xx_it.c stm32f4xx_hal_msp.c dap_link.c usb_descriptors.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/TinyUSB
    ../Middlewares/Third_Party/tinyusb/src/: tusb.c
    ../Middlewares/Third_Party/tinyusb/src/common/: tusb_fifo.c
    ../Middlewares/Third_Party/tinyusb/src/device/: usbd.c usbd_control.c
    ../Middlewares/Third_Party/tinyusb/src/portable/synopsys/dwc2/: dcd_dwc2.c dwc2_common.c
    ../Middlewares/Third_Party/tinyusb/src/class/cdc/: cdc_device.c
    ../Middlewares/Third_Party/tinyusb/src/class/vendor/: vendor_device.c
  group Middlewares/CMSIS-DAP
    ../Middlewares/Third_Party/cmsis-dap/Source/: DAP.c SW_DP.c JTAG_DP.c SWO.c DAP_vendor.c
  group Startup
    ./: startup_stm32f401xc.s
software components: CMSIS:CORE 6.1.0
